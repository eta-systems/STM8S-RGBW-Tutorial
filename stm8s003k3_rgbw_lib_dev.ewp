# IAR project stm8s003k3_rgbw_lib_dev.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S003K3 STM8S003K3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCIncludePath2: C:\Users\simon\Documents\STM8\stm8s003k3_rgbw_lib_dev\Drivers\ws2812b\inc; C:\Users\simon\Documents\STM8\stm8s003k3_rgbw_lib_dev\STM8S_StdPeriph_Driver\inc; C:\Users\simon\Documents\STM8\stm8s003k3_rgbw_lib_dev
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8s003k3_rgbw_lib_dev.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: main.c stm8s_conf.h stm8s_it.c stm8s_it.h
  group Drivers/ws2812/inc
    Drivers/ws2812b/inc/: ws2812b_conf.h WS2812B_FX.h ws2812b_LLD.h
  group Drivers/ws2812/src
    Drivers/ws2812b/src/: ws2812b_fx.c ws2812b_LLD.c
  group StdPeriph/inc
    STM8S_StdPeriph_Driver/inc/: stm8s.h stm8s_adc1.h stm8s_awu.h stm8s_beep.h stm8s_clk.h stm8s_exti.h stm8s_flash.h stm8s_gpio.h stm8s_i2c.h stm8s_itc.h stm8s_iwdg.h stm8s_rst.h stm8s_spi.h stm8s_tim1.h stm8s_tim2.h stm8s_tim4.h stm8s_uart1.h stm8s_wwdg.h
  group StdPeriph/src
    STM8S_StdPeriph_Driver/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
