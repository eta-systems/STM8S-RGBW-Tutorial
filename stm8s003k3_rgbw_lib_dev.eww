<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm8s003k3_rgbw_lib_dev.ewp</path>
    </project>
    <batchBuild />
</workspace>
